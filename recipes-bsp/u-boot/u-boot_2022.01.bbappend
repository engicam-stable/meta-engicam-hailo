FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-added-mxl-8611x-driver.patch file://0002-added-hailo15-smarcore-support.patch"

