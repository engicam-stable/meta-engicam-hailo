FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://devtool-fragment.cfg file://0001-added-mxl-8611x-driver.patch file://0002-added-first-hailo15-smarcore-support.patch"

